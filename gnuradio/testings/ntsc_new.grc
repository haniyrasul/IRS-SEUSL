options:
  parameters:
    author: Rasul
    generate_options: qt_gui
    id: ntsc_new
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 512000000+1250000
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Audio Delay
    start: '0'
    step: '10'
    stop: 240e3
    value: '0'
  states: {}
- name: digital_gain
  id: variable
  parameters:
    value: '0.9'
  states: {}
- name: if_gain
  id: variable
  parameters:
    value: '40'
  states: {}
- name: rf_gain
  id: variable
  parameters:
    value: '14'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: samples_per_line * 60 * .999 * 525 / 2
  states: {}
- name: samples_per_line
  id: variable
  parameters:
    value: '772'
  states: {}
- name: tx_freq
  id: variable_qtgui_range
  parameters:
    label: TX Frequency
    start: 100e6
    step: 10e6
    stop: 700e6
    value: center_freq
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: '48000'
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 4e6
    low_cutoff_freq: '-2475000 + 1725000'
    samp_rate: samp_rate
    type: fir_filter_ccc
    width: '500000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '0'
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: D:\University\Research\IRS\Video TxRx\testing.dat
    repeat: 'True'
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '110e-3'
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\University\Research\IRS\Video TxRx\audio\minions.mp4
    repeat: 'True'
  states: {}
- name: fosphor_qt_sink_c_0
  id: fosphor_qt_sink_c
  parameters:
    freq_center: center_freq
    freq_span: samp_rate
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-4.5e6'
    decim: '1'
    samp_rate: 12.15e6
    taps: '1'
    type: ccc
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '8800'
    send_eof: 'False'
    type: complex
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '0'
    freq0: tx_freq
    gain0: rf_gain
    if_gain0: if_gain
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_sig_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', fosphor_qt_sink_c_0, '0']
- [blocks_add_xx_0, '0', network_udp_sink_0, '0']
- [blocks_add_xx_0, '0', osmosdr_sink_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', blocks_delay_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [rational_resampler_xxx_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
